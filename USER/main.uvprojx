# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DEIVER
  c include: ..\Libraries\AIR32_USB-FS-Device_Driver\inc;..\Libraries\AIR32F10xLib\inc;..\Libraries\AIR32F10xLib\lib\cryptlib;..\Libraries\CMSIS\Include;..\Libraries\DELAY;..\USER;..\Libraries\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c main.h
  group OLED
    ./: oled.c oled.h oledfont.h
  group ADC
    ./: adc.c adc.h pwm.c key.c
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 1.0.0, Device:StdPeriph Drivers:Delay 1.0.0, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.0, Device:StdPeriph Drivers:I2C 1.0.0, Device:StdPeriph Drivers:RCC 1.0.0, Device:StdPeriph Drivers:TIM 1.0.0
